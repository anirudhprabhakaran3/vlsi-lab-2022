# NAND Gate

.include ./t14y_tsmc_025_level3.txt
